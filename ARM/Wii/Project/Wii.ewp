# IAR project Wii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\Include\; ..\Drivers\CMSIS\Include\; ..\Drivers\Peripherals\Include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/CMSIS/Header
    ../Drivers/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f4xx.h system_stm32f4xx.h
  group Drivers/CMSIS/Source
    ../Drivers/CMSIS/Source/: system_stm32f4xx.c
  group Drivers/Peripherals/Header
    ../Drivers/Peripherals/Include/: misc.h stm32f4xx_dbgmcu.h stm32f4xx_flash.h stm32f4xx_gpio.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h
  group Drivers/Peripherals/Source
    ../Drivers/Peripherals/Source/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group System
    ../Source/: startup_stm32f4xx.s
    ../Include/: stm32f4xx_conf.h
  group Wii/Header
    ../Include/: bluetooth.h leds.h main.h motor_driver.h stdafx.h uart.h
  group Wii/Source
    ../Source/: bluetooth.cpp interrupt.cpp leds.cpp main.cpp motor_driver.cpp uart.cpp
